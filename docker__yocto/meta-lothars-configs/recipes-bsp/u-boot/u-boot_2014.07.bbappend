## append patches and configs to the altera u-boot-socfpga (2019)
## save a defconfig via: $ make savedefconfig
##
#FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
#SRC_URI += "file://defconfig"
